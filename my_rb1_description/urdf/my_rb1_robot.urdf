Commit message: Added diff drive and laser plugins

File: my_rb1_description/urdf/my_rb1_robot.urdf (robot description, URDF)
Before this commit: robot rb1, 7 links, 6 joints
Links:
- link left_wheel: geometry collision cylinder length=0.04 radius=0.025; visual cylinder length=0.04 radius=0.025
